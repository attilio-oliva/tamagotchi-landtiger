# Keil uVision project sample.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sample
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SIMULATOR
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group startup_file
    ./: startup_LPC17xx.s
  group main
    ./: sample.c
  group lib_SoC_board
    ./: core_cm3.c system_LPC17xx.c
  group timer
    ./timer/: IRQ_timer.c lib_timer.c timer.h
  group GLCD
    ./GLCD/: AsciiLib.c AsciiLib.h GLCD.c GLCD.h HzLib.c HzLib.h
  group ecs
    ./engine/ecs/: data_types.c entity.c world.c component.h data_types.h entity.h world.h
  group RIT
    ./RIT/: IRQ_RIT.c lib_RIT.c RIT.h
  group debouncer
    ./custom_button/: button_utils.c button_utils.h
  group button
    ./button_EXINT/: button.h IRQ_button.c lib_button.c
  group joystick
    ./joystick/: joystick.h lib_joystick.c
  group adc
    ./adc/: adc.h IRQ_adc.c lib_adc.c
  group TouchPanel
    ./TouchPanel/: TouchPanel.c TouchPanel.h
  group manager
    ./engine/manager/: music.c music.h time.c time.h input.c input.h
  group game_entities
    ./game/entities/: age_textui.c age_textui.h creature.c creature.h cuddle_sfx.c cuddle_sfx.h happiness_imageui.c happiness_imageui.h hungriness_imageui.c hungriness_imageui.h meal.c meal.h menu_bar.c menu_bar.h menu_item_textui.c menu_item_textui.h reset_textui.c reset_textui.h snack.c snack.h volume_ui.c volume_ui.h
  group game
    ./game/: game.c game_music.h game_assets.h game.h
  group engine
    ./engine/: renderer.c renderer.h globals.h
software components: CMSIS:CORE 5.4.0
